options:
  parameters:
    author: abhilash
    generate_options: qt_gui
    id: AMC_TRIAL
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: NV
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.1'
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: eightpsk_
  id: variable_constellation
  parameters:
    precision: '8'
    type: 8psk
  states: {}
- name: qam
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '500'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: NV
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: digital_constellation_modulator_1
  id: digital_constellation_modulator
  parameters:
    constellation: eightpsk_
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: digital_constellation_modulator_1_0
  id: digital_constellation_modulator
  parameters:
    constellation: qam
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: digital_probe_mpsk_snr_est_c_1
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.001'
    msg_nsamples: '10000'
    type: '0'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '2'
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      from gnuradio import grc
      import inspect


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Multiplexer1',   # will show up in GRC
                  in_sig=[np.complex64,np.complex64,np.complex64],
                  out_sig=[np.complex64]
              )
              self.selectPortName = 'snr'
              self.message_port_register_in(pmt.intern(self.selectPortName))
              self.set_msg_handler(pmt.intern(self.selectPortName), self.handle_msg)
              self.last_snr = 0
              self.is_mod_changed=False;
              self.selector=0
              self.last_selector=0
              self.bpsk_max=8
              self.qpsk_max=9
              self.psk8_max=10
              #self.qam16_max=4
              self.tag_added=True
              self.index=0;
          
          def handle_msg(self, msg):
              self.last_snr=pmt.to_double(msg)
              if self.last_snr >=0 and self.last_snr < self.bpsk_max:
                  self.selector=0
              elif self.last_snr >= self.bpsk_max and self.last_snr < self.qpsk_max:
                  self.selector=1
              else:
                  self.selector=2
              #print(self.last_snr)
              if self.selector!=self.last_selector:
                  self.last_selector=self.selector
                  #print(self.selector)
                  self.tag_added=False
            

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              if self.tag_added!= True:
                  self.add_item_tag(0, self.nitems_written(0), pmt.intern('mod'), pmt.from_long(self.selector))
                  self.tag_added=True
              output_items[0][:] = input_items[self.selector]
              return len(output_items[0])
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: modulation after channel
    size: '1024'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: qpsk
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: qam16
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: bpsk
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: qpsk
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: bpsk
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: qam16
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', digital_constellation_modulator_0, '0']
- [blocks_throttle_0, '0', digital_constellation_modulator_1, '0']
- [blocks_throttle_0, '0', digital_constellation_modulator_1_0, '0']
- [blocks_throttle_0_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', digital_probe_mpsk_snr_est_c_1, '0']
- [channels_channel_model_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_constellation_modulator_0, '0', virtual_sink_0_1, '0']
- [digital_constellation_modulator_1, '0', virtual_sink_0, '0']
- [digital_constellation_modulator_1_0, '0', virtual_sink_0_0, '0']
- [digital_probe_mpsk_snr_est_c_1, snr, blocks_message_debug_0, print]
- [digital_probe_mpsk_snr_est_c_1, snr, epy_block_0_0, snr]
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [epy_block_0_0, '0', blocks_throttle_0_0, '0']
- [virtual_source_0, '0', epy_block_0_0, '1']
- [virtual_source_0_0, '0', epy_block_0_0, '0']
- [virtual_source_0_1, '0', epy_block_0_0, '2']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
